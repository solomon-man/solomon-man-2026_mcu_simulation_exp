# Keil uVision project 按键.uvproj, settings and files
target Target_1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(11059200)
  output: 按键 +hex
  c flags: Optimize=8 SizeSpeed=1
  group 按键
    ./: main.c key.c init.c led.c

# Keil uVision project 5.1.uvproj, settings and files
target Target_1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 5.1 +hex
  c flags: Optimize=8 SizeSpeed=1
  group 5.1流水灯
    ./: STARTUP.A51 main.c
